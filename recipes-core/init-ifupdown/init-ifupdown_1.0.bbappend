FILESEXTRAPATHS_prepend := "${THISDIR}/valid:"
